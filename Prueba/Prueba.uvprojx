# Keil uVision project Prueba.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK20DX256xxx7 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IROM2(0x10000000,0x8000) IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Prueba +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  group Source
    ./: main.c
  group Libs
    ./: ClockManager.c startup_MK20D7.s
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
